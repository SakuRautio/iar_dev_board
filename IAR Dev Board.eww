<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Device\Device.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Library\LibraryProject\STM32F4-Discovery\Library.ewp</path>
    </project>
    <batchBuild />
</workspace>
